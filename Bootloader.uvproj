# Keil uVision project Bootloader.uvproj, settings and files
target ReleasInFlash (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC177x_8x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c include: .\LPC177x_8x;.\CM3
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\LPC177x_8x.sct
  group CMSIS Files
    ./CM3/: core_cm3.c
    ./LPC177x_8x/: system_LPC177x_8x.c
    ./LPC177x_8x/Startup/: startup_LPC177x_8x.s
  group User Code
    ./USER_CODE/: main.c
  group IAP
    ./IAP/: IAP.c
  group CRC
    ./CRC/: crc.c
  group XMODEM-1K
    ./XMODEM1K/: xmodem1k.c
  group UART
    ./UART/: uart.c
target DebugInRAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: LPC177x_8x +hex
  c flags: Optim=1 OneElfS=1
  c define: __RAM_MODE__
  c include: .\LPC177x_8x;.\CM3
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
